<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\RealApp.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>RealApp</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>RealApp</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>RealApp</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>RealApp</project>
        <configuration>RouterZLight</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


